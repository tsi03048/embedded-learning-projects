# Keil uVision project UART_Integrated_AC6.uvproj, settings and files
target 01_UART_Integrated (6220000::V6.22::ARMCLANG)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x08000000-0x0807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 01_UART_Integrated +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F10X_HD
  c misc: -std=c99
  c include: .\CMSIS;.\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ./App/: main.c
  group CMSIS
    ./CMSIS/: system_stm32f10x.c startup_stm32f10x_hd.s

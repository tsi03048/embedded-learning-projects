# Keil uVision project Sensor_Monitor.uvproj, settings and files
target 01_Threshold_LED (6220000::V6.22::ARMCLANG)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x08000000-0x0807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 01_Threshold_LED +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD
  c misc: -std=c99
  c include: .\CMSIS;.\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ./App/: 01_threshold_led.c 02_hysteresis_led.c 03_timed_monitor.c 04_uart_report.c
  group CMSIS
    ./CMSIS/: system_stm32f10x.c startup_gpio_ac6.S
target 02_Hysteresis_LED (6220000::V6.22::ARMCLANG)
  device: STM32F103VE STMicroelectronics
  cpu: as above
  output: 02_Hysteresis_LED +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD
  c misc: -std=c99
  c include: .\CMSIS;.\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
target 03_Timed_Monitor (6220000::V6.22::ARMCLANG)
  device: STM32F103VE STMicroelectronics
  cpu: as above
  output: 03_Timed_Monitor +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD
  c misc: -std=c99
  c include: .\CMSIS;.\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
target 04_UART_Report (6220000::V6.22::ARMCLANG)
  device: STM32F103VE STMicroelectronics
  cpu: as above
  output: 04_UART_Report +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD
  c misc: -std=c99
  c include: .\CMSIS;.\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000

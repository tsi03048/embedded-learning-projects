# Keil uVision project UART_Flow.uvproj, settings and files
target 01_TX_One (6220000::V6.22::ARMCLANG)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x08000000-0x0807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 01_TX_One +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD
  c misc: -std=c99
  c include: .\CMSIS;.\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ./App/: 01_tx_one.c 02_rx_observe.c 03_poll_echo.c 04_rx_irq.c
  group CMSIS
    ./CMSIS/: system_stm32f10x.c startup_gpio_ac6.S
target 02_RX_Observe (6220000::V6.22::ARMCLANG)
  device: STM32F103VE STMicroelectronics
  cpu: as above
  output: 02_RX_Observe +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD
  c misc: -std=c99
  c include: .\CMSIS;.\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
target 03_Poll_Echo (6220000::V6.22::ARMCLANG)
  device: STM32F103VE STMicroelectronics
  cpu: as above
  output: 03_Poll_Echo +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD
  c misc: -std=c99
  c include: .\CMSIS;.\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
target 04_RX_IRQ (6220000::V6.22::ARMCLANG)
  device: STM32F103VE STMicroelectronics
  cpu: as above
  output: 04_RX_IRQ +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD
  c misc: -std=c99
  c include: .\CMSIS;.\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000

# Keil uVision project Wait_Limits.uvproj, settings and files
target 01_ADC_Bounded (6220000::V6.22::ARMCLANG)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x08000000-0x0807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 01_ADC_Bounded +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD
  c misc: -std=c99
  c include: .\CMSIS;.\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ./App/: 01_adc_bounded.c 02_uart_bounded.c 03_adc_observation_fault.c 04_txe_observation_fault.c 05_tc_observation_fault.c
  group CMSIS
    ./CMSIS/: system_stm32f10x.c startup_gpio_ac6.S
target 02_UART_Bounded (6220000::V6.22::ARMCLANG)
  device: STM32F103VE STMicroelectronics
  cpu: as above
  output: 02_UART_Bounded +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD
  c misc: -std=c99
  c include: .\CMSIS;.\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
target 03_ADC_Observation_Fault (6220000::V6.22::ARMCLANG)
  device: STM32F103VE STMicroelectronics
  cpu: as above
  output: 03_ADC_Observation_Fault +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD
  c misc: -std=c99
  c include: .\CMSIS;.\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
target 04_TXE_Observation_Fault (6220000::V6.22::ARMCLANG)
  device: STM32F103VE STMicroelectronics
  cpu: as above
  output: 04_TXE_Observation_Fault +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD
  c misc: -std=c99
  c include: .\CMSIS;.\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
target 05_TC_Observation_Fault (6220000::V6.22::ARMCLANG)
  device: STM32F103VE STMicroelectronics
  cpu: as above
  output: 05_TC_Observation_Fault +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD
  c misc: -std=c99
  c include: .\CMSIS;.\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000

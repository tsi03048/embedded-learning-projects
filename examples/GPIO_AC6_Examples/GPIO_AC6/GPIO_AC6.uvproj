# Keil uVision project GPIO_AC6.uvproj, settings and files
target 01_LED_Blink (6220000::V6.22::ARMCLANG)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x08000000-0x0807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 01_LED_Blink +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F10X_HD, LESSON_EXAMPLE=1
  c misc: -std=c99
  c include: .\CMSIS;.\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ./App/: main.c debounce.c
  group CMSIS
    ./CMSIS/: system_stm32f10x.c startup_stm32f10x_hd.s
target 02_Button_Raw (6220000::V6.22::ARMCLANG)
  device: STM32F103VE STMicroelectronics
  cpu: as above
  output: 02_Button_Raw +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F10X_HD, LESSON_EXAMPLE=2
  c misc: -std=c99
  c include: .\CMSIS;.\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
target 03_Debounce_READY_RUN (6220000::V6.22::ARMCLANG)
  device: STM32F103VE STMicroelectronics
  cpu: as above
  output: 03_Debounce_READY_RUN +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F10X_HD, LESSON_EXAMPLE=3
  c misc: -std=c99
  c include: .\CMSIS;.\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
